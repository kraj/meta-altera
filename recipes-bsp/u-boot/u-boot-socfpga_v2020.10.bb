require u-boot-socfpga-common.inc

UBOOT_VERSION = "v2020.10"

SRCREV = "c79c23c6201819ca32b6739eff2e2b25e19f6624"

LIC_FILES_CHKSUM = "file://Licenses/README;md5=5a7450c57ffe5ae63fd732446b988025"
