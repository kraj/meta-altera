require u-boot-socfpga-common.inc

UBOOT_VERSION = "v2021.01"

SRCREV = "c11f4e161a2d86a3657fbbc21f87bc4afb815eb9"

LIC_FILES_CHKSUM = "file://Licenses/README;md5=5a7450c57ffe5ae63fd732446b988025"
