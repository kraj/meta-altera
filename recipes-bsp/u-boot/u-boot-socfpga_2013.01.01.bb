# SoCEDS 15.1 u-Boot release
UBOOT_TAG = "353283b6e75eabdcc48dadf08507b4b86c229d78"

require u-boot-socfpga.inc
