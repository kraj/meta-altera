require u-boot-socfpga-common.inc

UBOOT_VERSION = "v2021.04"

SRCREV = "fcb08e4ed98723cfe2e9521e6cf91f8781507d43"

LIC_FILES_CHKSUM = "file://Licenses/README;md5=5a7450c57ffe5ae63fd732446b988025"
