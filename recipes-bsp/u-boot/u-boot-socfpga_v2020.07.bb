require u-boot-socfpga-common.inc

UBOOT_VERSION = "v2020.07"

SRCREV = "9ad6dad583130e600e835a0d3ff821359b9dc9ab"
