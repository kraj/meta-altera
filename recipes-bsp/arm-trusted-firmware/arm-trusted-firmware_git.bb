require arm-trusted-firmware.inc

SRCREV = "a124a308dc3125480ca9c746afb48007d9a7ffce"
