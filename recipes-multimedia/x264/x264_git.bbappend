INSANE_SKIP_${PN}_append = " textrel"
