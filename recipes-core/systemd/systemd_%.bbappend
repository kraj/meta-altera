FILESEXTRAPATHS_prepend := "${THISDIR}/systemd:"
SRC_URI += "file://0001-Add-support-for-nios2.patch"
