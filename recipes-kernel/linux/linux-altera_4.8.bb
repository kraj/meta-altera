LINUX_VERSION = "4.8"

SRCREV = "560ef2cb450a27c17519eb09fd5b97226859605a"

include linux-altera.inc
