DTB_SUBDIR="dts/"

KERNEL_DEVICETREE = "socfpga_cyclone5_socdk socfpga_arria5_socdk socfpga_vt"

require recipes-kernel/linux/linux-altera-latest.inc

