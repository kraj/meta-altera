LINUX_VERSION = "4.7"

SRCREV = "e18ed5786335e7fa6a0b9a418d6d59cceb80ba47"

include linux-altera.inc
