LINUX_VERSION = "4.4"

SRCREV = "84eb65f84ea7a15cd73766fb16e6a868dc7a734b"

include linux-altera.inc
