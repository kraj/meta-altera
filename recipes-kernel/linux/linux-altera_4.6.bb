LINUX_VERSION = "4.6"

SRCREV = "9d08abae8b2cf7dbc69c7e17b84109906ed9c721"

include linux-altera.inc
