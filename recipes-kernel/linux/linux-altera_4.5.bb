LINUX_VERSION = "4.5"

SRCREV = "091b0c145676d926977c64dce3f34631a8caa12d"

include linux-altera.inc
