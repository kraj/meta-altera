LINUX_VERSION = "4.9"

SRCREV = "bed10ef01d8bfbc883a6bc4400aecc79709b45f1"

include linux-altera.inc
