LINUX_VERSION = "4.1.33"
LINUX_VERSION_SUFFIX = "-ltsi"

SRCREV = "bb7cdf57951e4b365ee3f1505322ac568fd5d72b"

include linux-altera.inc

